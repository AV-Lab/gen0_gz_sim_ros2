Commit message: SDF file collision update

File: gen0_simulator/src/gen0_main/urdf/description.urdf.xacro (robot description, xacro)
@@ -489,5 +489,4 @@
       <origin xyz="0 0 0" rpy="0 0 0"/>
       <geometry>
-    <box size="0.1 0.1 0.1"/>
       </geometry>
     </collision>
